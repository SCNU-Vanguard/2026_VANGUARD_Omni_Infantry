# Keil uVision project 2026_VANGUARD_Frame.uvprojx, settings and files
target 2026_VANGUARD_Frame (6230000::V6.23::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: 2026_VANGUARD_Frame
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/ARM/DSP/Inc;../bsp/DWT;../bsp/USART;../bsp/CAN;../bsp/I2C;../bsp/SPI;../bsp/FLASH;../bsp/TIM;../bsp/PWM;../bsp/ADC;../bsp/GPIO;../module/buzzer;../module/imu;../module/led;../module/vofa;../module/led/WS2812;../module/motor;../module/remote;../module/defense_center;../module/message_center;../algorithm;../algorithm/controller;../algorithm/controller/PID;../module/motor/DJI_motor;../module/motor/DM_motor;../algorithm/basic_function;../application/chassis;../application/communication_bond;../application/gimbal;../application/shoot;../algorithm/filter;../algorithm/filter/AHRS;../algorithm/filter/AHRS/madgwick;../algorithm/filter/AHRS/mahony;../algorithm/filter/EKF;../algorithm/filter/kalman;../Middlewares/ST/ARM/DSP/Lib;../application;../application/alarm_system;../application/INS;../module/imu/BMI088;../module/remote/WFLY;../module/remote/DT7;../algorithm/controller/VMC;../algorithm/filter/normal;../algorithm/filter/LPF;../algorithm/filter/OLS;../algorithm/filter/RLS;../algorithm/filter/LMS;../module/motor/LK_motor;../module/rs485;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../module/motor/SHOOT_motor;../module/referee;../application/ShooterUI;../module/remote/VT03;../module/super_cap;../algorithm/power_control;..\application\New_UI
  asm include: ../Middlewares/ST/ARM/DSP/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: 2026_VANGUARD_Frame.sct
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c i2c.c rng.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group bsp
    ../bsp/DWT/: bsp_dwt.c bsp_dwt.h
    ../bsp/PWM/: bsp_pwm.c bsp_pwm.h
    ../bsp/CAN/: bsp_can.c bsp_can.h
    ../bsp/USART/: bsp_usart.c bsp_usart.h
    ../bsp/SPI/: bsp_spi.c bsp_spi.h
    ../bsp/GPIO/: bsp_gpio.c bsp_gpio.h
    ../bsp/I2C/: bsp_iic.c bsp_iic.h
  group module
    ../module/defense_center/: defense_center.c defense_center.h
    ../module/message_center/: message_center.c message_center.h
    ../module/led/WS2812/: ws2812.c ws2812.h
    ../module/vofa/: vofa.c vofa.h
    ../module/buzzer/: buzzer.c buzzer.h
    ../module/imu/: bmi088.c bmi088.h bmi088_reg.h
    ../module/motor/: drv_motor.c drv_motor.h
    ../module/motor/DJI_motor/: DJI_motor.c DJI_motor.h
    ../module/motor/DM_motor/: DM_motor.c DM_motor.h
    ../module/remote/DT7/: remote_control.c remote_control.h
    ../module/remote/WFLY/: wfly_control.c wfly_control.h
    ../module/motor/LK_motor/: LK_motor.c LK_motor.h
    ../module/rs485/: rs485.c rs485.h
    ../module/motor/SHOOT_motor/: shoot_motor.c shoot_motor.h
    ../module/referee/: referee.c referee.h
    ../module/remote/VT03/: remote_vt03.c remote_vt03.h
    ../module/super_cap/: super_cap.c super_cap.h
  group algorithm
    ../application/: robot_frame_config.c
    ../algorithm/controller/PID/: pid.c pid.h digital_pid.c digital_pid.h
    ../algorithm/basic_function/: user_lib.c user_lib.h signal_generator.c signal_generator.h CRC.c CRC.h
    ../algorithm/filter/AHRS/madgwick/: MadgwickAHRS.c MadgwickAHRS.h
    ../algorithm/filter/AHRS/mahony/: MahonyAHRS.c MahonyAHRS.h
    ../algorithm/filter/EKF/: QuaternionEKF.c QuaternionEKF.h
    ../algorithm/filter/kalman/: kalman_filter.c kalman_filter.h
    ../algorithm/filter/: kalman_one_filter.c kalman_one_filter.h mahony_filter.c mahony_filter.h
    ../algorithm/controller/VMC/: vmc.c vmc.h
    ../algorithm/filter/normal/: normal_filter.c normal_filter.h
    ../algorithm/filter/LPF/: lpf.c lpf.h
    ../algorithm/filter/OLS/: ols.c ols.h
    ../algorithm/filter/RLS/: rls.c rls.h
    ../algorithm/filter/LMS/: lms.c lms.h
    ../algorithm/power_control/: PowerCtrl.c PowerCtrl.h
  group application
    ../application/: robot_frame_config.h robot_frame_init.c robot_frame_init.h
    ../application/chassis/: chassis.c chassis.h chassis_task.h chassis_task.c
    ../application/gimbal/: gimbal.h gimbal.c gimbal_task.c gimbal_task.h
    ../application/shoot/: shoot.c shoot.h shoot_task.c shoot_task.h
    ../application/alarm_system/: daemon.c daemon.h daemon_task.c daemon_task.h
    ../application/INS/: INS.c INS.h INS_task.c INS_task.h
    ../application/communication_bond/: procotol.c procotol.h procotol_task.c procotol_task.h VPC.c VPC.h Serial.c Serial.h
    ../application/ShooterUI/: ui.c ui.h ui_Infantry_group1_0.c ui_Infantry_group1_0.h ui_Infantry_group1_1.c ui_Infantry_group1_1.h ui_Infantry_group1_2.c ui_Infantry_group1_2.h ui_Infantry_group1_3.c ui_Infantry_group1_3.h ui_Infantry_group1_4.c ui_Infantry_group1_4.h ui_Infantry_group2_0.c ui_Infantry_group2_0.h ui_interface.c ui_interface.h ui_types.h
    ../application/New_UI/: referee_protocol.h referee_task.c referee_task.h referee_UI.c referee_UI.h rm_referee.c rm_referee.h
  group DSP
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM7lfdp_math.lib
  group BMI088
    ../module/imu/BMI088/: BMI088driver.c BMI088driver.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h
  group omni_mecanum_chassis
    ../application/chassis/: omni_mecanum_chassis.c omni_mecanum_chassis.h
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 6.1.1
